# IAR project RFID.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: HARDWARE/Usart; HARDWARE/RFID; HARDWARE/Delay; HARDWARE/OLED; HARDWARE/OLEDIIC; HARDWARE/Lamp; HARDWARE/Rs485; HARDWARE/Time
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group HARDWARE
    HARDWARE/Delay/: delay.c
    HARDWARE/Lamp/: Lamp.c
    HARDWARE/OLED/: OLED.c
    HARDWARE/OLEDIIC/: OLEDIIC.c
    HARDWARE/RFID/: RC522.c
    HARDWARE/Rs485/: Rs485.c
    HARDWARE/Time/: Time.c
    HARDWARE/Usart/: Usart.c
