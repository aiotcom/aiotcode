# Keil uVision project IPV4_TCP_Server.uvprojx, settings and files
target IPv4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CORE;..\USER;..\OBJ;..\SYSTEM\delay;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\HARDWARE\LED;..\SYSTEM\SYS_INT;..\HARDWARE\delay;..\HARDWARE\RS485;..\HARDWARE\USART;..\HARDWARE\uip_1_0\apps\webserver;..\HARDWARE\uip_1_0\uip;..\HARDWARE\uip_1_0\lib;..\HARDWARE\uip_1_0\unix;..\HARDWARE\ENC28J60;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_msp.c
  group CORE
    ../CORE/: core_cm3.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f103xe.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi.c
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/USART/: USART.c USART.h
    ../HARDWARE/RS485/: RS485.c RS485.h
    ../../IPV4_TCP_Server/HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
    ../HARDWARE/TIMER/: _timer.c _timer.h
  group uip_1_0_lib
    ../HARDWARE/uip_1_0/lib/: memb.c memb.h
  group uip_1_0_uip
    ../HARDWARE/uip_1_0/uip/: clock.h lc.h lc-addrlabels.h lc-switch.h psock.c psock.h pt.h timer.c timer.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip-fw.c uip-fw.h uiplib.c uiplib.h uip-neighbor.c uip-neighbor.h uipopt.h uip-split.c uip-split.h
  group uip_1_0_http
    ../HARDWARE/uip_1_0/apps/webserver/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c
  group uip_1_0_apps
    ../HARDWARE/uip_1_0/unix/: clock-arch.c clock-arch.h tapdev.c tapdev.h uIP_App.c uIP_App.h uIP_AppCall.c uIP_AppCall.h uip-conf.h
  group ENC28J60
    ../HARDWARE/ENC28J60/: enc28j60.c enc28j60.h ip_arp_udp_tcp.c ip_arp_udp_tcp.h net.h spi_enc28j60.c spi_enc28j60.h web_server.c web_server.h
