# IAR project SHT20.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: HARDWARE/SHT20; HARDWARE/Delay; HARDWARE/IIC; HARDWARE/TM1640; HARDWARE/Lamp; HARDWARE/Rs485; HARDWARE/Usart; HARDWARE/Time; HARDWARE/ADC
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group HARDWARE
    HARDWARE/ADC/: ADC.c
    HARDWARE/Delay/: delay.c
    HARDWARE/IIC/: IIC.c
    HARDWARE/Lamp/: Lamp.c
    HARDWARE/Rs485/: Rs485.c
    HARDWARE/SHT20/: SHT20.c
    HARDWARE/Time/: Time.c
    HARDWARE/TM1640/: TM1640.c
    HARDWARE/Usart/: Usart.c
