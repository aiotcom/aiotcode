# Keil uVision project UHF_RFID.uvprojx, settings and files
target UHF_RFID (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CORE;..\USER;..\OBJ;..\SYSTEM\delay;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\HARDWARE\LED;..\SYSTEM\SYS_INT;..\HARDWARE\delay;..\HARDWARE\LORA;..\HARDWARE\Rs485;..\HARDWARE\Usart;..\HARDWARE\CC2500;..\HARDWARE\Platform_RGB_LED;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_msp.c
  group CORE
    ../CORE/: core_cm3.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f103xe.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/Rs485/: Rs485.c Rs485.h
    ../HARDWARE/Usart/: Usart.c Usart.h
    ../HARDWARE/CC2500/: CC2500.c CC2500.h CC2500_reg.h
    ../HARDWARE/Platform_RGB_LED/: Platform_RGB_LED.c Platform_RGB_LED.h
    ../HARDWARE/TIMER/: timer.c timer.h
