# IAR project light_switch.ewp, settings and files
configuration srf05_cc2530 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/Components/utils; ../../../source/Components/common; ../../../source/Components/basicrf; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/Components/common/cc8051; ../../../source/Components/targets/srf05_soc; ../../../source/Components/radios/cc2530; ../../../source/apps/Usart; ../../../source/apps/Delay; ../../../source/apps/SHT20; ../../../source/apps/IIC; ../../../source/apps/TM1640; ../../../source/apps/OLEDIIC; ../../../source/apps/OLED
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.0 Evaluation\8051\config\lnk51e.xcl
  group application
    ../../../source/apps/Delay/: delay.c
    ../../../source/apps/IIC/: IIC.c
    ../../../source/apps/light_switch/: light_switch.c
    ../../../source/apps/OLED/: OLED.c
    ../../../source/apps/OLEDIIC/: OLEDIIC.c
    ../../../source/apps/SHT20/: SHT20.c
    ../../../source/apps/TM1640/: TM1640.c
    ../../../source/apps/Usart/: Usart.c
  group basic rf
    ../../../source/Components/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group hal/common
    ../../../source/Components/common/cc8051/: hal_cc8051.h
    ../../../source/Components/common/: hal_defs.h hal_int.c hal_types.h
    ../../../source/Components/targets/common/: hal_lcd_srf05.c
  group hal/interface
    ../../../source/Components/targets/interface/: hal_assert.h hal_button.h hal_digio.h hal_int.h hal_joystick.h hal_lcd.h hal_led.h hal_mcu.h
  group hal/rf
    ../../../source/Components/targets/interface/: hal_rf.h hal_rf_security.h
  group hal/rf/cc2530
    ../../../source/Components/radios/cc2530/: adc.c adc.h clock.c clock.h hal_mcu.c hal_rf.c hal_rf_security.c
  group hal/srf05_soc
    ../../../source/Components/targets/srf05_soc/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_digio.c hal_joystick.c hal_led.c
  group utilities
    ../../../source/Components/utils/: util.c util.h util_buffer.c util_buffer.h util_lcd.c util_lcd.h
