# IAR project project.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: UIP_UDP=1; UIP_BUFSIZE=300; UIP_CONNS=5
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: source/ENC28J60/; source/uip/apps/webserver/; source/uip/uip/; source/uip/lib/; source/uip/appcall; source/; source/basicrf; source/HAL/
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group basic_rf
    source/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group HAL
    source/HAL/: clock.c clock.h hal_defs.h hal_int.c hal_int.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h TIM.c TIM.h UART.c UART.h util.c util.h
  group LORA
    source/: LORA.c LORA.h
  group USER
    source/: inttypes.h main.c type.h
